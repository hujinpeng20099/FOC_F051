# Keil uVision project f072_enc.uvprojx, settings and files
target f072_enc (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: f072_enc +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM0,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F072xB
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../MCSDK_v5.Y.2/MotorControl/MCSDK/MCLib/Any/Inc;../MCSDK_v5.Y.2/MotorControl/MCSDK/MCLib/F0xx/Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Application/User
    ../Src/: main.c motorcontrol.c mc_api.c mc_config.c mcp_config.c mc_tasks.c pwm_curr_fdbk.c regular_conversion_manager.c mc_math.c mc_interface.c stm32f0xx_mc_it.c mc_parameters.c register_interface.c usart_aspep_driver.c mc_configuration_registers.c aspep.c stm32f0xx_it.c stm32f0xx_hal_msp.c
    ../User/: uc1705.c hmi_task.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_adc.c stm32f0xx_ll_dma.c stm32f0xx_ll_rcc.c stm32f0xx_ll_utils.c stm32f0xx_ll_exti.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Middlewares/MotorControl
    ../MCSDK_v5.Y.2/MotorControl/lib/: libmc-keil_M0.lib
    ../MCSDK_v5.Y.2/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c enc_align_ctrl.c encoder_speed_pos_fdbk.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_speed_sensor.c mcp.c
    ../MCSDK_v5.Y.2/MotorControl/MCSDK/MCLib/F0xx/Src/: r3_f0xx_pwm_curr_fdbk.c
software components: CMSIS:CORE 4.3.0
